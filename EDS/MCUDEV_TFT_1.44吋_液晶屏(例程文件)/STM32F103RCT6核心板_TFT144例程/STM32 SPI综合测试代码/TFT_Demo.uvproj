# Keil uVision project TFT_Demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-FLASHLED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: stm32f10x_it.c main.c Lcd_Driver.c delay.c GUI.c TFT_demo.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c
  group CMSYS
    ./user/: core_cm3.c system_stm32f10x.c
