# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051K6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: main +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\CMSIS;..\USER;..\USMART;..\STM32F051x_FWLib\inc;..\HARDWARE\TFT;..\HARDWARE\LED;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../CMSIS/: system_stm32f0xx.c stm32f0xx_conf.h startup_stm32f0xx.s stm32f0xx_it.c
  group USER
    ./: main.c system.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TFT/: TFT_SPI.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group STM32F051x_FWLib
    ../: STM32F051R8_FWLib.lib
